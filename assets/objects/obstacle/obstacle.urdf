Commit message: obstacle debug

File: assets/objects/obstacle/obstacle.urdf (robot description, URDF)
Before this commit: robot obstacle.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.03 .4 .1; visual box size=.03 0.4 .1
